## src/modules/auv_hopf/Kconfig
```kconfig
menuconfig MODULES_AUV_HOPF
    bool "auv_hopf"
    default n
    ---help---
        AUV Hopf-TubeMPC composite control module
```
